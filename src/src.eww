<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\src.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>src</name>
      <member>
        <project>src</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


