# IAR project src.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_WDG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; lib\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: src.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F105x8 ST STM32F105x8
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: STM32F10x_StdPeriph_Driver\inc; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: comm.srec
  ILINK.IlinkIcfFile: comm.icf
  group (top)
    ./: buzz.c com.c core_cm3.c database.c flash.c led.c main.c proc.c pwm.c rfid.c rtc.c startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c tick.c uart.c wdg.c
    lib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
